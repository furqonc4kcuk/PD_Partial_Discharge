<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Partial_Discharge.ewp</path>
  </project>
  <batchBuild />
</workspace>
